# Keil uVision project lcd_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lcd_test
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 lcdtest.c
    ../../程序源码/LCD1602驱动代码/: LCD1602.c LCD1602.h
